Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2021-07-06T07:15:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jul 06 07:15:54 2021 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{904DB755-A323-429C-9695-A852F9EE72EC}\ifc * Database version: 5507 * Database creation date: Tue Jul 06 07:15:52 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jul 06 07:15:53 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jul 06 07:15:53 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 28707835_CH_11212630_DA7078D_BRWS, 11212630_CH_DA7078D_BRWS:28707835_CH_11212630_DA7078D_BRWS:206987
In: Level 1
Type - Material: z_Miele_Design_CLST, z_Miele_Design_Steel_Chrom, z_Miele_Design_Glass, z_Miele_Design_Powder Coat_Lotus White, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - Reference: 28707835_CH_11212630_DA7078D_BRWS
Pset_ManufacturerTypeInformation - Manufacturer: Miele
